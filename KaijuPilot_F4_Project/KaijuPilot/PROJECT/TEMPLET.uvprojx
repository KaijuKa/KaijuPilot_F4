# Keil uVision project TEMPLET.uvprojx, settings and files
target TEMPLET (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMPLET +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\SYSTEM\io;..\HARDWARE;..\SYSTEM\math
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/: key.c key.h led.c led.h pwm.c pwm.h spi.c spi.h uart.c uart.h icm20602.c icm20602.h imu.c imu.h remote_signal.c remote_signal.h schedule.c schedule.h msgInterchange.c msgInterchange.h flight_ctrl.c flight_ctrl.h arg_manage.c arg_manage.h att_ctrl.c att_ctrl.h iic.c iic.h at24c02.c at24c02.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/io/: io.h
    ../SYSTEM/math/: kaiju_math.c kaiju_math.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
